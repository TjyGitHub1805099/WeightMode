# Keil uVision project firmware_wm_00_app.uvprojx, settings and files
target app (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F303RC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: firmware_wm_00_app +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\STM32F303DriverLib\reg;..\STM32F303DriverLib\inc;..\firm_wm_00_hal\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group lib
    ../STM32F303DriverLib/Objects/: STM32F303DriverLib.lib
    ../firm_wm_00_hal/Objects/: firmware_wm_00_hal.lib
  group src
    ./src/: app_main.c app_main_task.c app_led_ctrl.c app_hx711_ctrl.c app_sdwe_ctrl.c app_key_ctrl.c app_crc.c app_modbus_rtu_ctrl.c app_password.c app_syspara.c app_systest.c app_t5l_ctrl.c app_t5l_cfg.c app_InnerScreen_Cfg.c app_InnerScreen_Cfg_6.c app_InnerScreen_Cfg_12.c app_InnerScreen_Cfg_16.c
  group inc
    ./inc/: app_led_ctrl.h app_sdwe_ctrl.h app_hx711_ctrl.h app_key_ctrl.h app_main_task.h app_crc.h app_modbus_rtu_ctrl.h app_password.h app_syspara.h app_systest.h app_t5l_ctrl.h app_t5l_cfg.h app_InnerScreen_Cfg.h
  group startup
    ./startup/: startup_stm32f30x.s
